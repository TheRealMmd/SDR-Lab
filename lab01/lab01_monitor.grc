options:
  parameters:
    generate_options: qt_gui
    id: lab01_monitor
    output_language: python
    title: SDR Lab 01 Monitor
  states: {}

blocks:
- name: f_tune
  id: variable
  parameters:
    value: int(fc + lo_shift)
  states: {}
- name: fc
  id: variable
  parameters:
    value: 945e6
  states: {}
- name: lo_shift
  id: variable_qtgui_range
  parameters:
    label: LO Shift (Hz)
    rangeType: int
    start: '-1000000'
    step: '100000'
    stop: '1000000'
    value: '0'
  states: {}
- name: rec
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Record I/Q
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rec_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    label0: 2.6M
    label1: 5M
    label2: 10M
    label3: 20M
    num_opts: '4'
    option0: '2600000'
    option1: '5000000'
    option2: '10000000'
    option3: '20000000'
    type: int
    value: '2600000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport json\nfrom datetime import datetime, timezone\nfrom pathlib import Path\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"SDR Lab IQ Recorder\"\"\"\n\n    def __init__(\n        self,\n        fc=945e6,\n        fs=2.6e6,\n        gain=10.0,\n        record=False,\n        max_seconds=10.0,\n    ):\n        gr.sync_block.__init__(\n            self,\n            name=\"SDR Lab IQ Recorder\",\n            in_sig=[np.complex64],\n            out_sig=[]\n        )\n\n        # Parameters controlled by GRC\n        self.fc = fc\n        self.fs = fs\n        self.gain = gain\n        self.record = record\n        self.max_seconds = max_seconds\n\n        # Recording state\n        self._file = None\n        self._path = None\n        self._samples_written = 0\n        self._target_samples = 0\n        self._armed = True\n        self._metadata = None\n\n    def _start_recording(self):\n        fs = float(self.fs)\n        duration = float(self.max_seconds)\n\n        if fs <= 0 or duration <= 0:\n            raise ValueError(\n                \"fs and max_seconds must be positive\"\n            )\n\n        folder = Path.home() / \"SDR_Lab_Recordings\"\n        folder.mkdir(parents=True, exist_ok=True)\n\n        timestamp = datetime.now().strftime(\n            \"%Y%m%d_%H%M%S_%f\"\n        )\n        self._path = folder / f\"iq_{timestamp}.c64\"\n\n        self._file = open(self._path, \"wb\")\n        self._samples_written = 0\n        self._target_samples = max(\n            1, int(fs * duration)\n        )\n\n        self._metadata = {\n            \"center_frequency_hz\": float(self.fc),\n            \"sample_rate_hz\": fs,\n            \"rx_gain_db\": float(self.gain),\n            \"max_seconds\": duration,\n            \"data_type\": \"complex64\",\n            \"started_utc\": datetime.now(\n                timezone.utc\n            ).isoformat(),\n        }\n\n        print(\"Recording started:\", self._path)\n\n    def _stop_recording(self, reason):\n        if self._file is None:\n            return\n\n        self._file.close()\n        self._file = None\n\n        self._metadata[\"samples_written\"] = (\n            self._samples_written\n        )\n        self._metadata[\"recorded_seconds\"] = (\n            self._samples_written\n            / self._metadata[\"sample_rate_hz\"]\n        )\n        self._metadata[\"stop_reason\"] = reason\n\n        metadata_path = self._path.with_suffix(\n            \".json\"\n        )\n\n        with open(\n            metadata_path, \"w\", encoding=\"utf-8\"\n        ) as f:\n            json.dump(self._metadata, f, indent=2)\n\n        print(\"Recording saved:\", self._path)\n\n    def work(self, input_items, output_items):\n        samples = input_items[0]\n        n = len(samples)\n\n        # Checkbox disabled\n        if not bool(self.record):\n            if self._file is not None:\n                self._stop_recording(\"User stopped\")\n\n            self._armed = True\n            return n\n\n        # Start only once per checkbox activation\n        if self._armed and self._file is None:\n            self._start_recording()\n\n        if self._file is not None:\n            remaining = (\n                self._target_samples\n                - self._samples_written\n            )\n            count = min(n, remaining)\n\n            if count > 0:\n                self._file.write(\n                    samples[:count].tobytes()\n                )\n                self._samples_written += count\n\n            if (\n                self._samples_written\n                >= self._target_samples\n            ):\n                self._stop_recording(\n                    \"Maximum duration reached\"\n                )\n                self._armed = False\n\n        return n\n\n    def stop(self):\n        self._stop_recording(\"Flowgraph stopped\")\n        return True\n"
    fc: f_tune
    fs: samp_rate
    gain: rf_gain
    max_seconds: rec_sec
    record: rec
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: f_tune
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_tune
    fftsize: '1024'
    name: Frequency Spectrum
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: I/Q Time Domain
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: f_tune
    fftsize: '1024'
    name: Waterfall
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
