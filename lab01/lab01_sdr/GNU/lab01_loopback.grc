options:
  parameters:
    generate_options: qt_gui
    id: lab01_loopback
    output_language: python
    title: lab01_loopback
  states: {}

blocks:
- name: f_tune
  id: variable
  parameters:
    value: int(fc + lo_shift)
  states: {}
- name: f_tx
  id: variable_qtgui_range
  parameters:
    label: f_tx(hz)
    start: '-1e6'
    step: 50e3
    stop: 1e6
    value: 250e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc(hz)
    start: 325e6
    step: 16e6
    stop: 3.8e9
    value: 945e6
    widget: counter
  states: {}
- name: lo_shift
  id: variable_qtgui_range
  parameters:
    label: Lo Shift(hz)
    orient: QtCore.Qt.Vertical
    start: '-500e3'
    step: 10e3
    stop: 500e3
    value: '0'
    widget: counter
  states: {}
- name: rec
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Record I/Q
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: rec_sec
  id: variable
  parameters:
    value: ' min(4.0, 80e6/(8*samp_rate))'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Rf Gain (db)
    start: '0'
    step: '1'
    stop: '10'
    value: '10'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    label0: 2.6 MS/s
    label1: 5 MS/s
    label2: 10 MS/s
    label3: 20 MS/s
    num_opts: '4'
    option0: '2600000'
    option1: '5000000'
    option2: '10000000'
    option3: '20000000'
    type: int
    value: '2600000'
  states: {}
- name: team
  id: variable
  parameters:
    value: '"Team-07"'
  states: {}
- name: tx_att
  id: variable_qtgui_range
  parameters:
    label: TX attenuation(db)
    start: '40'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: uri
  id: variable
  parameters:
    value: ' "ip:192.168.1.10"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: f_tx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import time
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """GNU Radio sink block for recording raw complex64 I/Q samples."""

          IDLE = "IDLE"
          RECORDING = "RECORDING"
          WAIT = "WAIT"

          def __init__(self, team='Team-00', lab=1, fc=100e6, fs=2.6e6,
                       gain=0.0, record=False, max_seconds=5.0, folder='.'):
              gr.sync_block.__init__(self,
                                     name='SDR Lab IQ Recorder',
                                     in_sig=[np.complex64],
                                     out_sig=None)

              # Keep the parameter names exactly as declared: GNU Radio updates these
              # attributes when the corresponding block parameters change at runtime.
              self.team = team
              self.lab = lab
              self.fc = fc
              self.fs = fs
              self.gain = gain
              self.record = record
              self.max_seconds = max_seconds
              self.folder = folder

              # Internal state
              self._state = self.IDLE
              self._file = None
              self._written = 0
              self._n_max = 0
              self._start_settings = None

          def _open_file(self):
              """Create a new recording file and initialize its per-file counters."""
              os.makedirs(self.folder, exist_ok=True)

              self._n_max = int(np.floor(float(self.max_seconds) * float(self.fs)))
              # Round before converting to int, as required for floating-point
              # frequency/sample-rate values supplied by GNU Radio.
              fc_hz = int(round(float(self.fc)))
              fs_hz = int(round(float(self.fs)))
              gain_db = float(self.gain)

              # The required timestamp has one-second resolution. If a recording
              # with the same parameters already used this exact name in this second,
              # wait for the next timestamp rather than silently overwriting it.
              while True:
                  timestamp = time.strftime('%Y%m%dT%H%M%S')
                  filename = (
                      f"{self.team}_lab{int(self.lab):02d}_"
                      f"{fc_hz}_{fs_hz}_{gain_db:.1f}_{timestamp}.cf32"
                  )
                  filepath = os.path.join(self.folder, filename)
                  if not os.path.exists(filepath):
                      break
                  time.sleep(0.05)

              self._file = open(filepath, 'wb')
              self._written = 0
              self._start_settings = (float(self.fc), float(self.fs), float(self.gain))

              print(f"[REC] start {filename}")

          def _close_file(self, reason):
              """Close the active file and print a summary of the recording."""
              if self._file is None:
                  return

              # Use the sample rate captured when this file was opened. The live
              # parameter may already have changed when this helper is called.
              start_fs = self._start_settings[1]
              duration = (self._written / start_fs) if start_fs > 0 else 0.0

              self._file.close()
              self._file = None
              print(f"[REC] stop  {self._written} samples = {duration:.2f} s ({reason})")

          def work(self, input_items, output_items):
              x = input_items[0]

              if self._state == self.IDLE:
                  if self.record:
                      # Guard: a recording shorter than one sample makes no sense.
                      # Go to WAIT so the message is printed once, not on every call.
                      if float(self.max_seconds) * float(self.fs) < 1:
                          print("[REC] error: max_seconds * fs < 1 sample, "
                                "nothing to record")
                          self._state = self.WAIT
                          return len(x)

                      # Guard: if the folder/file cannot be created, report it and
                      # keep the flowgraph (spectrum displays) running. WAIT means
                      # the next attempt happens only after Record is re-ticked.
                      try:
                          self._open_file()
                      except OSError as e:
                          print(f"[REC] error: cannot open file ({e})")
                          self._file = None
                          self._state = self.WAIT
                          return len(x)

                      self._state = self.RECORDING

                      # The first input batch must also be recorded.
                      k = min(len(x), self._n_max - self._written)
                      if k > 0:
                          x[:k].tofile(self._file)
                          self._written += k

                      if self._written >= self._n_max:
                          self._close_file('max_seconds reached')
                          self._state = self.WAIT

              elif self._state == self.RECORDING:
                  # Check conditions in the exact priority order from the lab spec.
                  if not self.record:
                      self._close_file('record off')
                      self._state = self.IDLE

                  elif ((float(self.fc), float(self.fs), float(self.gain))
                        != self._start_settings):
                      self._close_file('settings changed')
                      self._state = self.WAIT

                  else:
                      remaining = self._n_max - self._written
                      k = min(len(x), remaining)
                      if k > 0:
                          x[:k].tofile(self._file)
                          self._written += k

                      if self._written >= self._n_max:
                          self._close_file('max_seconds reached')
                          self._state = self.WAIT

              elif self._state == self.WAIT:
                  if not self.record:
                      self._state = self.IDLE
                  # While record remains True, do nothing. This prevents a second
                  # file from starting until the user unchecks and checks Record.

              return len(x)

          def stop(self):
              if self._file is not None:
                  self._close_file('flowgraph stopped')
              return True
    fc: f_tune
    folder: '"recordings"'
    fs: samp_rate
    gain: rf_gain
    lab: '1'
    max_seconds: rec_sec
    record: rec
    team: team
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: int(fc)
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: f_tune
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: f_tune
    fftsize: '1024'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: f_tune
    fftsize: '1024'
    int_max: '-20'
    int_min: '-110'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
